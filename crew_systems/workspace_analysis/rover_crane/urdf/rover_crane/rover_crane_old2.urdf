Commit message: balling

File: crew_systems/workspace_analysis/rover_crane/urdf/rover_crane/rover_crane_old2.urdf (robot description, URDF)
Before this commit: robot rover_crane, 8 links, 7 joints
Joints:
- joint tip_joint: parent crane_link4 -> cclrane_link4
