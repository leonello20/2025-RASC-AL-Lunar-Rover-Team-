Commit message: less pain

File: crew_systems/workspace_analysis/dymaflight/urdf/rover_crane_dyma.urdf (robot description, URDF)
Before this commit: robot rover_crane, 17 links, 16 joints
Joints:
- joint tippy_to_base: origin xyz=0 0 -1.054 rpy=0 3.14159 0 -> xyz=0 -0.1 -1.0 rpy=1.5708 0 0
